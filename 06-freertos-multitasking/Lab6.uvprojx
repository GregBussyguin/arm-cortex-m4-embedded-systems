# Keil uVision project Lab6.uvprojx, settings and files
target EK-TM4C1294XL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab6 +hex
  AfterMake: fromelf.exe --bin Objects\Lab6.axf --output Objects\Lab6.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\TivaWare_C_Series-2.2.0.295;C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S main.c
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./: FreeRTOSConfig.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
