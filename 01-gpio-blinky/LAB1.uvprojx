# Keil uVision project LAB1.uvprojx, settings and files
target EK-TM4C1294XL (6160000::V6.16::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --std=c99
  c include: ..\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: main.c startup_rvmdk.S
  group Documentation
    ./: readme.txt
  group Library
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.1.0
